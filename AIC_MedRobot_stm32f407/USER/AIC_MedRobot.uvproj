# Keil uVision project AIC_MedRobot.uvproj, settings and files
target AIC_MedRobot (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: AIC_MedRobot +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\LED;..\HARDWARE\PWM;..\HARDWARE\EXTI;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\TIMER;..\HARDWARE\ADC;..\HARDWARE\LCD;..\HARDWARE\TOUCH;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\UI;..\HARDWARE\GBK_LibDrive;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\OV2640;..\HARDWARE\DCMI;..\HARDWARE\CAMERA;..\HARDWARE\ATK-ESP8266;..\HARDWARE\USART3;..\HARDWARE\USART2;..\HARDWARE\WIFI_TRANSFER;..\HARDWARE\MOTOR;..\RTOS;..\RTOS\FreeRTOS-Kernel;..\RTOS\FreeRTOS-Kernel\include;..\RTOS\FreeRTOS-Kernel\portable;..\RTOS\FreeRTOS-Kernel\portable\MemMang;..\RTOS\FreeRTOS-Kernel\portable\RVDS;..\RTOS\FreeRTOS-Kernel\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c car_app.c wifi_cmd.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/TOUCH/: touch.c ctiic.c gt9147.c ott2001a.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/UI/: ui.c ui_zh_font.c
    ../HARDWARE/OV2640/: ov2640.c sccb.c
    ../HARDWARE/DCMI/: dcmi.c
    ../HARDWARE/CAMERA/: camera.c
    ../HARDWARE/ATK-ESP8266/: common.c wifista.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/WIFI_TRANSFER/: wifi_transfer.c
    ../HARDWARE/MOTOR/: motor.c
  group RTOS
    ../RTOS/: rtos_app.c FreeRTOSConfig.h
    ../RTOS/FreeRTOS-Kernel/: list.c queue.c tasks.c
    ../RTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ../RTOS/FreeRTOS-Kernel/portable/RVDS/ARM_CM4F/: port.c
